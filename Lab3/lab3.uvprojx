# Keil uVision project lab3.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab3
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\CORE;.\STM32F10x_FWLib\inc;.\RTE\Device\STM32F103RC;.\USER;.\HARDWARE\KEY;.\HARDWARE\LED;.\SYSTEM\delay;.\SYSTEM\sys
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source
    ./: main.c
  group System
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/LED/: led.c
  group Device
    ./RTE/Device/STM32F103RC/: system_stm32f10x.c
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./USER/: stm32f10x_it.c
