# Keil uVision project lab3key_LED.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab3key_LED
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\HARDWARE\KEY;.\HARDWARE\LED;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: main.c
  group Hardware
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/LED/: led.c
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
software components: CMSIS:CORE 3.40.0, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
